# Keil uVision project LED.uvprojx, settings and files
target LED (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\LCD;..\SYSTEM\Usart;..\HARDWARE\DHT11;..\HARDWARE\TIMER;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\MQTT;..\HARDWARE\onenet;..\HARDWARE\esp8266;..\SYSTEM\sys;..\HARDWARE\cJSON;..\HARDWARE\MPU6050\DMP;..\HARDWARE\MPU6050\IIC;..\HARDWARE\MPU6050;..\HARDWARE\WDG
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c help.txt
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU6050/IIC/: IIC.c
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/WDG/: wdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/Usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_iwdg.c
  group README
    ../: README.TXT
  group NET
    ../HARDWARE/esp8266/: esp8266.c
    ../HARDWARE/MQTT/: MqttKit.c
    ../HARDWARE/onenet/: onenet.c
    ../HARDWARE/cJSON/: cJSON.c
